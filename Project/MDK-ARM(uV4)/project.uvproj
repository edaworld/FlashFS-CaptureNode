# Keil uVision project project.uvproj, settings and files
target Flash (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: STM32F103RD STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x805FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: output +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c misc: --diag_suppress=870
  c include: ..\..\Libraries\CMSIS\Device\ST\STM32F10x\Include;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\User\bsp;..\..\User\bsp\inc;..\..\User;..\..\Libraries\CMSIS\Include;..\..\RL-ARM\Config;..\..\RL-ARM\Driver;..\..\User\app
  memory RVCT4: ROM 0x8000000 size 0x60000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../../User/: main.c includes.h Retarget.c
    ../../RL-ARM/Config/: File_Config.c File_Config.h
  group BSP
    ../../User/bsp/: bsp.c bsp.h stm32f10x_it.c stm32f10x_assert.c
    ../../User/bsp/src/: bsp_led.c bsp_uart_fifo.c bsp_uartpro.c bsp_cpu_rtc.c bsp_timer.c bsp_rf.c bsp_sx1276-LoRa.c bsp_spi2.c bsp_user_lib.c
  group MDK-ARM
    ../../Libraries/CMSIS/Device/ST/STM32F10x/Source/Templates/arm/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_bkp.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_rtc.c stm32f10x_spi.c
  group CMSIS
    ../../User/bsp/: system_stm32f10x.c
  group RL-FlashFS/Lib
    ../../RL-ARM/RL-FlashFS/: FSN_CM3.lib
  group RL-FlashFS/Driver
    ../../RL-ARM/Driver/: SDIO_STM32F103.c SDIO_STM32F103.h
  group RL-FlashFS/Time
    ../../RL-ARM/RL-FlashFS/: fs_time.c
  group OS
    ../../User/bsp/: bsp_tpc.c
  group Doc
    ../../Doc/: 01.例程功能说明.txt 02.开发环境说明.txt
